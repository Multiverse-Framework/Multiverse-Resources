Commit message: Add sdf

File: objects/table/table.urdf (robot description, URDF)
Before this commit: robot table, 1 links, 0 joints
Links:
- link table: geometry collision box size=0.10000000149011612 0.10000000149011612 1.0; collision box size=0.10000000149011612 0.10000000149011612 1.0
